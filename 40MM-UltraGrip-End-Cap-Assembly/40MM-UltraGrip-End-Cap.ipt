# Autodesk Inventor part: 40MM-UltraGrip-End-Cap
## iProperties
Created: 2012-04
Part Number: 40MM-UltraGrip-End-Cap
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
